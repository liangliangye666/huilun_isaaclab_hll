Commit message: feat: 适配马哥代码20260805的训练配置

File: resources/robots/l5a/urdf/l5aurdf20260521.urdf (robot description, URDF)
Before this commit: robot l5aurdf20260521, 9 links, 8 joints
Links:
- link left_wheel_link: mass 1.5825 -> 1.232459
- link right_wheel_link: mass 1.5838 -> 1.233799
